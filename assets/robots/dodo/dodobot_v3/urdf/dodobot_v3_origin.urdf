Commit message: more urdf files

File: assets/robots/dodo/dodobot_v3/urdf/dodobot_v3_origin.urdf (robot description, URDF)
Before this commit: robot dodobot_v3, 9 links, 8 joints
Joints:
- joint left_joint_3: axis 0 0 1 -> 0 0 -1
